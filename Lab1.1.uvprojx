# Keil uVision project Lab1.1.uvprojx, settings and files
target Lab1.1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: _Lab1.1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\Board;.\Core;.\Fw_lib\inc;.\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Fw_lib
    ./Fw_lib/src/: stm32f10x_rcc.c stm32f10x_gpio.c
  group Core
    ./Core/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group User
    ./User/: main.c stm32f10x_it.c
  group Board
    ./Board/: EIE3810_clock.c EIE3810_clock.h EIE3810_EXTI.c EIE3810_EXTI.h EIE3810_GPIO.c EIE3810_GPIO.h EIE3810_TFTLCD.h EIE3810_TIM.c EIE3810_TIM.h EIE3810_USART.c EIE3810_USART.h game.c game.h EIE3810_TFTLCD.c
